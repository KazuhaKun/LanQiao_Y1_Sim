# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c ds1302.c ds1302.h iic.c iic.h onewire.c onewire.h init.c init.h key.c key.h led.c led.h seg.c seg.h uart.c uart.h ultrawave.c ultrawave.h
