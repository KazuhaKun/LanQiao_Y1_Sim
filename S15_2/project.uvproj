# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ds1302.c ds1302.h iic.c iic.h Init.c Init.h Key.c Key.h Led.c Led.h main.c onewire.c onewire.h Seg.c Seg.h Uart.c Uart.h ultrasound.c ultrasound.h
